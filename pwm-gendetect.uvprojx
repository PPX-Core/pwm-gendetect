# Keil uVision project pwm-gendetect.uvprojx, settings and files
target PWM-GenDetect (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: pwm +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\App;.\CMSIS;.\STM32F0xx_HAL_Driver\Inc;.\HAL
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group App
    ./App/: main.c stm32f0xx_it.c pwm_in.c pwm_out.c
  group CMSIS
    ./CMSIS/: system_stm32f0xx.c startup_stm32f030x6.s
  group Driver
    ./STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_ll_adc.c stm32f0xx_ll_dma.c stm32f0xx_ll_gpio.c stm32f0xx_ll_pwr.c stm32f0xx_ll_rcc.c stm32f0xx_ll_tim.c stm32f0xx_ll_utils.c
  group HAL
    ./HAL/: hal_adc.c hal_ic.c hal_lcd.c hal_led.c hal_key.c hal_pwm.c hal_tim.c
